INSANE_SKIP:${PN}-ptest += "build-deps file-rdeps"

RDEPENDS:checkmk += "gawk"

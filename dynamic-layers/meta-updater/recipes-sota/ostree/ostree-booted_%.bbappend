# FILES:${PN} += "${exec_prefix}/"

# DEPENDS:append = " dnf-native repo-native"

ROOTFS_BOOTSTRAP_INSTALL += "os-release-initrd"

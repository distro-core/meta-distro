IMAGE_ROOTFS_SIZE = "2097152"
IMAGE_ROOTFS_MAXSIZE = "2097152"

EFI_PROVIDER = "l4t-launcher"

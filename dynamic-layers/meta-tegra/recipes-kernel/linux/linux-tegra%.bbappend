require recipes-kernel/linux/distro-linux-tegra.inc
require recipes-kernel/linux/distro-sierra-wireless-mbpl.inc

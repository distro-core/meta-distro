require recipes-kernel/linux/distro-linux-raspberrypi.inc
require recipes-kernel/linux/distro-sierra-wireless-mbpl.inc

FILES:${PN}:append = " ${libdir}/"

PACKAGECONFIG:remove = "doc templates"

RDEPENDS:${PN} += "perl-module-autodie"

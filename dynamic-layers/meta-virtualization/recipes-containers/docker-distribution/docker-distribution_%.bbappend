SYSTEMD_AUTO_ENABLE:docker-registry = "disable"

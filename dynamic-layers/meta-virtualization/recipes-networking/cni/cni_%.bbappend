# INSANE_SKIP:${PN} += "ldflags ldflags already-stripped textrel"

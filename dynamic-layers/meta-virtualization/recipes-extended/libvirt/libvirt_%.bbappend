# INSANE_SKIP:${PN} += "build-deps"

# INSANE_SKIP:${PN}-python += "buildpaths"

# DEPENDS += "base-passwd"

DEPENDS += "itstool-native"

PACKAGES += "${PN}-dev"
ALLOW_EMPTY:${PN}-dev = "1"
RDEPENDS:${PN}-dev += ""

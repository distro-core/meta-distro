INSANE_SKIP:${PN} += "32bit-time"

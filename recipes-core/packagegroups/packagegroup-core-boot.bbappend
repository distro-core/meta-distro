RDEPENDS:${PN} += "${MACHINE_ESSENTIAL_EXTRA_RDEPENDS}"

RRECOMMENDS:${PN} += "${MACHINE_ESSENTIAL_EXTRA_RRECOMMENDS}"

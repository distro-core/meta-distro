RDEPENDS:packagegroup-core-sdk:append = " \
${SANITIZERS} \
git \
libgomp \
libgomp-dev \
repo \
"

DEPENDS += "libqmi libmbim"

EXTRA_OECONF += "--disable-rilmodem"

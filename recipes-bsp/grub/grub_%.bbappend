INSANE_SKIP:${PN}-common += "build-deps"

RCONFLICTS:${PN} += "grub systemd-boot u-boot"

RCONFLICTS:${PN} += "systemd-bootconf"

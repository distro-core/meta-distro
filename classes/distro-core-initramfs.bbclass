# File: distro-core-initramfs.bbclass
# SPDX-License-Identifier: MIT

# ---

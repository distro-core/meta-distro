# IMAGE_FSTYPES:append = "tar.wsl"

IMAGE_CMD:wsl() {
    bbnote "IMAGE_CMD:wsl ${OTA_SYSROOT}"
}

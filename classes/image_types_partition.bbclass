# File: image_types_partition.bbclass
# SPDX-License-Identifier: MIT

GPT_DISK_UUID = "30270cfc-a254-417b-97d6-837f7d66f2d3"

# discoverable partitions and static uuid
# https://uapi-group.org/specifications/specs/discoverable_partitions_specification/

# TODO: This file has values that are utilized in scripts for the initramfs as well
# the image post processing.

GPT_PART_NAME_ESP = "ESP"
GPT_PART_UUID_ESP = "84a95e8f-d603-445d-8db2-9dc9851f306c"
GPT_PART_TYPE_ESP = "c12a7328-f81f-11d2-ba4b-00a0c93ec93b"
FSYS_DEV_NAME_ESP = "${GPT_PART_NAME_ESP}"
FSYS_DEV_UUID_ESP = "0x00455350"
FSYS_DEV_TYPE_ESP = "fat"
FSYS_DEV_UUID_ESP_FSTAB = "0045-5350"

GPT_PART_NAME_XBOOTLDR = "boot"
GPT_PART_UUID_XBOOTLDR = "9d8b9767-1a2d-4b9d-bbf4-1b100ff17dbf"
GPT_PART_TYPE_XBOOTLDR = "bc13c2ff-59e6-4262-a352-b275fd6f7172"
FSYS_DEV_NAME_XBOOTLDR = "${GPT_PART_NAME_XBOOTLDR}"
FSYS_DEV_UUID_XBOOTLDR = "0d17685c-744c-43f0-94fc-a5142430dbce"
FSYS_DEV_TYPE_XBOOTLDR = "ext4"

GPT_PART_NAME_VERITY = "root_verity"
GPT_PART_UUID_VERITY = "5ac15e3d-ca16-4dea-a04a-9f0d4981f257"
GPT_PART_TYPE_VERITY:arm = "7386cdf2-203c-47a9-a498-f2ecce45a2d6"
GPT_PART_TYPE_VERITY:aarch64 = "df3300ce-d69f-4c92-978c-9bfb0f38d820"
GPT_PART_TYPE_VERITY:x86 = "d13c5d3b-b5d1-422a-b29f-9454fdc89d76"
GPT_PART_TYPE_VERITY:x86-64 = "2c7357ed-ebd2-46d9-aec1-23d437ec2bf5"

GPT_PART_NAME_VERITY_SIG = "root_verity_sig"
GPT_PART_UUID_VERITY_SIG = "cdafb6e2-dc69-42c6-985a-3fa07e1021dc"
GPT_PART_TYPE_VERITY_SIG:arm = "42b0455f-eb11-491d-98d3-56145ba9d037"
GPT_PART_TYPE_VERITY_SIG:aarch64 = "6db69de6-29f4-4758-a7a5-962190f00ce3"
GPT_PART_TYPE_VERITY_SIG:x86 = "5996fc05-109c-48de-808b-23fa0830b676"
GPT_PART_TYPE_VERITY_SIG:x86-64 = "41092b05-9fc8-4523-994f-2def0408b176"

GPT_PART_NAME_ROOT = "root"
GPT_PART_UUID_ROOT = "23f18f75-540b-4b38-bba9-577c0f176b7a"
GPT_PART_TYPE_ROOT:arm = "69dad710-2ce4-4e3c-b16c-21a1d49abed3"
GPT_PART_TYPE_ROOT:aarch64 = "b921b045-1df0-41c3-af44-4c6f280d3fae"
GPT_PART_TYPE_ROOT:x86 = "44479540-f297-41b2-9af7-d131d5f0458a"
GPT_PART_TYPE_ROOT:x86-64 = "4f68bce3-e8cd-4db1-96e7-fbcaf984b709"
FSYS_DEV_NAME_ROOT = "${GPT_PART_NAME_ROOT}"
FSYS_DEV_UUID_ROOT = "2edb9829-5a6f-4dad-bafa-fdd8c1dab8dc"
FSYS_DEV_TYPE_ROOT = "ext4"

GPT_PART_NAME_USRVERITY = "usr_verity"
GPT_PART_UUID_USRVERITY = "c1e7a991-839e-4b24-9072-26aff87ca20d"
GPT_PART_TYPE_USRVERITY:arm = "c215d751-7bcd-4649-be90-6627490a4c05"
GPT_PART_TYPE_USRVERITY:aarch64 = "6e11a4e7-fbca-4ded-b9e9-e1a512bb664e"
GPT_PART_TYPE_USRVERITY:x86 = "77ff5f63-e7b6-4633-acf4-1565b864c0e6"
GPT_PART_TYPE_USRVERITY:x86-64 = "2c7357ed-ebd2-46d9-aec1-23d437ec2bf5"

GPT_PART_NAME_USRVERITY_SIG = "usr_verity_sig"
GPT_PART_UUID_USRVERITY_SIG = "70e5eccc-676d-4f60-8b5d-375d57b11565"
GPT_PART_TYPE_USRVERITY_SIG:arm = "d7ff812f-37d1-4902-a810-d76ba57b975a"
GPT_PART_TYPE_USRVERITY_SIG:aarch64 = "c23ce4ff-44bd-4b00-b2d4-b41b3419e02a"
GPT_PART_TYPE_USRVERITY_SIG:x86 = "974a71c0-de41-43c3-be5d-5c5ccd1ad2c0"
GPT_PART_TYPE_USRVERITY_SIG:x86-64 = "e7bb33fb-06cf-4e81-8273-e543b413e2e2"

GPT_PART_NAME_USR = "usr"
GPT_PART_UUID_USR = "4587a9a6-4523-425d-89ec-3b9fa91f0cfd"
GPT_PART_TYPE_USR:arm = "7d0359a3-02b3-4f0a-865c-654403e7062"
GPT_PART_TYPE_USR:aarch64 = "b0e01050-ee5f-4390-949a-9101b17104e9"
GPT_PART_TYPE_USR:x86 = "75250d76-8cc6-458e-bd66-bd47cc81a81"
GPT_PART_TYPE_USR:x86-64 = "8484680c-9521-48c6-9c11-b0720656f69e"
FSYS_DEV_NAME_USR = "${GPT_PART_NAME_USR}"
FSYS_DEV_UUID_USR = "dd43298a-269d-43ff-b983-8d4553766800"
FSYS_DEV_TYPE_USR = "ext4"

GPT_PART_NAME_HOME = "home"
GPT_PART_UUID_HOME = "587b0d0f-2adc-407e-89d2-dd79d64413c5"
GPT_PART_TYPE_HOME = "933ac7e1-2eb4-4f13-b844-0e14e2aef915"
FSYS_DEV_NAME_HOME = "${GPT_PART_NAME_HOME}"
FSYS_DEV_UUID_HOME = "73a4428b-7e82-4b6c-a9cd-492ae43a3bc0"
FSYS_DEV_TYPE_HOME = "ext4"

GPT_PART_NAME_SRV = "srv"
GPT_PART_UUID_SRV = "b33f0781-54a0-4da3-99e1-a12d6f649358"
GPT_PART_TYPE_SRV = "3b8f8425-20e0-4f3b-907f-1a25a76f98e8"
FSYS_DEV_NAME_SRV = "${GPT_PART_NAME_SRV}"
FSYS_DEV_UUID_SRV = "46a9fccc-655d-45ef-a729-7aaff2545b87"
FSYS_DEV_TYPE_SRV = "ext4"

GPT_PART_NAME_USER = "user"
GPT_PART_UUID_USER = "587b0d0f-2adc-407e-89d2-dd79d64413c5"
GPT_PART_TYPE_USER = "773f91ef-66d4-49b5-bd83-d683bf40ad16"
FSYS_DEV_NAME_USER = "${GPT_PART_NAME_USER}"
FSYS_DEV_UUID_USER = "1d48bfa5-67cc-4f4b-9417-b67b2f430864"
FSYS_DEV_TYPE_USER = "ext4"

GPT_PART_NAME_SWAP = "swap"
GPT_PART_UUID_SWAP = "7ce8a212-170e-46b7-80a7-6e07ac348506"
GPT_PART_TYPE_SWAP = "0657fd6d-a4ab-43c4-84e5-0933c84b4f4f"
FSYS_DEV_UUID_SWAP = "c4cae796-9296-418c-b09a-0097ed75ef22"
FSYS_DEV_TYPE_SWAP = "${GPT_PART_NAME_SWAP}"

GPT_PART_NAME_VAR = "var"
GPT_PART_UUID_VAR = "a2d85505-5728-465f-aad0-03f6f40043eb"
GPT_PART_TYPE_VAR = "4d21b016-b534-45c2-a9fb-5c16e091fd2d"
FSYS_DEV_NAME_VAR = "${GPT_PART_NAME_VAR}"
FSYS_DEV_UUID_VAR = "2d271dc0-079c-4889-9420-d44170d238e8"
FSYS_DEV_TYPE_VAR = "ext4"

GPT_PART_NAME_LIB = "var_lib"
GPT_PART_UUID_LIB = "6e91e62d-895c-4273-97c6-b4d0dc93b109"
GPT_PART_TYPE_LIB = "da6c0bd3-3ae8-4e73-a0f2-992551d10f79"
FSYS_DEV_NAME_LIB = "${GPT_PART_NAME_LIB}"
FSYS_DEV_UUID_LIB = "58202091-7f70-4cc0-b162-fc17658ff197"
FSYS_DEV_TYPE_LIB = "ext4"

GPT_PART_NAME_LOG = "var_log"
GPT_PART_UUID_LOG = "7d96fb19-d048-4854-9e7e-a232bcff31ab"
GPT_PART_TYPE_LOG = "f612c67b-38cd-4f40-bde0-ec2517fe0f13"
FSYS_DEV_NAME_LOG = "${GPT_PART_NAME_LOG}"
FSYS_DEV_UUID_LOG = "a268ce67-7526-4cb7-82f5-f83743284c3e"
FSYS_DEV_TYPE_LOG = "ext4"

GPT_PART_NAME_AUDIT = "var_log_audit"
GPT_PART_UUID_AUDIT = "bec2d651-04b5-4aac-b893-f967ac250b77"
GPT_PART_TYPE_AUDIT = "3de1c791-4912-481c-9426-8c72ada9d76e"
FSYS_DEV_NAME_AUDIT = "${GPT_PART_NAME_AUDIT}"
FSYS_DEV_UUID_AUDIT = "4f5237c5-ae62-4d53-ab68-8b8f546dfcb3"
FSYS_DEV_TYPE_AUDIT = "ext4"

GPT_PART_NAME_TMP = "var_tmp"
GPT_PART_UUID_TMP = "6f77024c-1e8a-4616-8171-078de4ce02de"
GPT_PART_TYPE_TMP = "7ec6f557-3bc5-4aca-b293-16ef5df639d1"
FSYS_DEV_NAME_TMP = "${GPT_PART_NAME_TMP}"
FSYS_DEV_UUID_TMP = "cee08fd0-afa1-42cd-af9b-58cda2c7f310"
FSYS_DEV_TYPE_TMP = "ext4"

GPT_PART_NAME_DATA = "data"
GPT_PART_UUID_DATA = "bc522c9e-520f-4665-ae95-5a636b55669d"
GPT_PART_TYPE_DATA = "0fc63daf-8483-4772-8e79-3d69d8477de4"

GPT_PART_NAME_LUKS = "cryptluks"
GPT_PART_UUID_LUKS = "f4ea7a37-617f-49db-bf41-a11826edda18"
GPT_PART_TYPE_LUKS = "ca7d7ccb-63ed-4c53-861c-1742536059cc"
FSYS_DEV_NAME_LUKS = "${GPT_PART_NAME_LUKS}"
FSYS_DEV_UUID_LUKS = "e2c8bea9-749d-4dcd-a2a2-617a16e82b0a"
FSYS_DEV_TYPE_LUKS = "luks2"

GPT_PART_NAME_LVM = "lvm"
GPT_PART_UUID_LVM = "e1249d4b-14d5-4901-aeef-fee054543188"
GPT_PART_TYPE_LVM = "e6d6d379-f507-44c2-a23c-238f2a3df928"

# ---

require recipes-kernel/linux/distro-linux-yocto.inc
require recipes-kernel/linux/distro-sierra-wireless-mbpl.inc

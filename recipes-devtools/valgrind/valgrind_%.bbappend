# meta-updater
SRC_URI:remove = "file://bug344802-unhandled-0xec510f1e.patch"

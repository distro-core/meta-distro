INSANE_SKIP:${PN}-ptest += "build-deps file-rdeps"

PACKAGECONFIG:remove = "readline"

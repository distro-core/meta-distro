DEPENDS:append = " libcap-ng attr"
RDEPENDS:${PN}:append = " libcap-ng attr"
